Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-06-21T04:22:14
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (8)
Name | FlowDirection
4 x  | SOURCE
4 x  | SINK

# IfcFlowTerminal: LA-40014-B-E
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: LA-40014-G-E
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: LA-40014-R-E
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: LA-40014-W-E
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Lightalk 10 Recessed Wall luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour RGBW 30,40,65 - Die-cast aluminium end-caps, extruded aluminium housing and sheet aluminium front frame pre-treated before powder coating ensuring high corrosion resistance - Stainless steel frame on request - Single cable entry - Through wiring on request - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - Clear toughened glass - Integral control gear - Recessing box is not included; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Lightalk, Recessed Wall luminaires; Housing color: White, Black, Silver
General Information - Weight: 6.2 kg; Case length: 26 cm; Case width: 125 cm; Case height: 9 cm; Article name: Lightalk 10 Recessed Wall luminaires; Uld creation date: 21.06.2019 03:22:13
Mounting Information - Mounting height: 180 cm
Photometric Information - Light output ratio: 1.00025; Luminous flux: 1471.64 lm; Lamp names: LA-40014-R-E
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 18.5 W
Pset_LightFixtureTypeCommon - NumberOfSources: 4; TotalWattage: 18.5 W; LightFixtureMountingType: WallRecessed; LightFixturePlacingType: Wall; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 824.651 lm; LightEmitterNominalPower: 14.2 W; Spectrum: 380: 0.002732, 385: 0.001636, 390: 0.00446, 395: 0, 400: 0.003259, 405: 0.000043, 410: 0.000067, 415: 0.00008, 420: 0.000784, 425: 0.006957, 430: 0.000135, 435: 0.001308, 440: 0.009081, 445: 0, 450: 0.00009, 455: 0.001087, 460: 0.000687, 465: 0.00598, 470: 0.006609, 475: 0.000092, 480: 0.00663, 485: 0, 490: 0.00146, 495: 0.000039, 500: 0.000851, 505: 0.001252, 510: 0.000112, 515: 0.005823, 520: 0.00154, 525: 0.000725, 530: 0.005191, 535: 0.002225, 540: 0.003952, 545: 0, 550: 0.000044, 555: 0.004258, 560: 0.003464, 565: 0.003893, 570: 0.010965, 575: 0.023605, 580: 0.046391, 585: 0.093667, 590: 0.155921, 595: 0.276011, 600: 0.492912, 605: 0.860002, 610: 1.53121, 615: 2.55622, 620: 4.03904, 625: 6.28586, 630: 8.09416, 635: 6.08711, 640: 2.9451, 645: 1.2389, 650: 0.555234, 655: 0.299846, 660: 0.194193, 665: 0.122602, 670: 0.088499, 675: 0.075667, 680: 0.053426, 685: 0.047708, 690: 0.033622, 695: 0.024902, 700: 0.016338, 705: 0.00543, 710: 0.014221, 715: 0.008547, 720: 0.011231, 725: 0.003263, 730: 0.001564, 735: 0, 740: 0.014794, 745: 0.001883, 750: 0.024508, 755: 0.003014, 760: 0.015277, 765: 0.021694, 770: 0.013646, 775: 0.000165, 780: 0.000223; ColorAppearance: K; ColorTemperature: 7247 K; ColorRenderingIndex: 80
